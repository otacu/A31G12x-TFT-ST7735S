# Keil uVision project A31G12x-TFT-ST7735S.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: A31G12x-TFT-ST7735S +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\source\Main;..\source\Device\ABOV\A31G12x\Include;..\source\Drivers\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Main
    ../source/Main/: A31G12x_it.c A31G12x_PortInit.c A31G12x_SystemClock.c main.c lcd.c SPI.c delay.c GUI.c test.c
  group Device
    ../source/Device/ABOV/A31G12x/Source/: system_A31G12x.c
  group Drivers
    ../source/Drivers/Source/: A31G12x_hal_adc.c A31G12x_hal_crc.c A31G12x_hal_debug_frmwrk.c A31G12x_hal_fmc.c A31G12x_hal_i2cn.c A31G12x_hal_intc.c A31G12x_hal_lcd.c A31G12x_hal_pcu.c A31G12x_hal_pwr.c A31G12x_hal_scu.c A31G12x_hal_sculv.c A31G12x_hal_timer1n.c A31G12x_hal_timer2n.c A31G12x_hal_timer3n.c A31G12x_hal_uartn.c A31G12x_hal_usart1n.c A31G12x_hal_wdt.c A31G12x_hal_wt.c
  group Startup
    ../source/Device/ABOV/A31G12x/Source/ARM/: startup_A31G12x.s
software components: CMSIS:CORE 5.2.0
